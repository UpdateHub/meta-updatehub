# libarchive configuration
PACKAGECONFIG_append = " xz lzo"
