inherit setuptools3
require recipes-devtools/python/python-asn1crypto.inc
